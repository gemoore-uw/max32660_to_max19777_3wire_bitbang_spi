# Keil uVision project max32660_to_max19777_3wire_bitbang_spi.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MAX32660 Maxim
  pack: Maxim.MAX32660.1.4.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: max32660_to_max19777_3wire_bitbang_spi
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source
    ../elapsed_time/: elapsed_time.c
    ../: main.c
  group Include
    ../elapsed_time/: elapsed_time.h
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MAX32660 Maxim
  pack: Maxim.MAX32660.1.4.0
  cpu: as above
  output: max32660_to_max19777_3wire_bitbang_spi
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 5.1.1, BSP:Board Support 1.4.0, Communications:I2C 1.4.0, Communications:SPI 1.4.0, Communications:UART 1.4.0, Device:Startup 1.4.0, Peripherals:GPIO 1.4.0, Peripherals:RTC 1.4.0, Peripherals:Timers 1.4.0
